# IAR project MCU_GENERATED.ewp, settings and files
configuration MCU_GENERATED (ARM, debug)
  General.OGChipSelectEditMenu: STM32F051C6 ST STM32F051C6
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F051x8
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32F0xx_HAL_Driver/Inc; ../Drivers/STM32F0xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Include; ../Drivers/CMSIS/Device/ST/STM32F0xx/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: MCU_GENERATED.out
  ILINK.IlinkIcfFile: stm32f051x8_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Drivers
    ./: 
  group Drivers/STM32F0xx_HAL_Driver
    ./: 
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_tim_ex.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_i2c.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_dma.c stm32f0xx_hal.c stm32f0xx_hal_gpio.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_cortex.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_flash.c stm32f0xx_hal_tim.c stm32f0xx_hal_rcc.c stm32f0xx_hal_uart.c
  group Drivers/CMSIS
    ./: 
    ../Drivers/CMSIS//Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
  group Application
    ./: 
  group Application/EWARM
    ./: 
    ../Drivers/CMSIS/Device/ST/STM32F0xx/Source/Templates/iar/: startup_stm32f051x8.s
  group Application/User
    ./: 
    ../Src/: main.c stm32f0xx_hal_msp.c stm32f0xx_it.c
